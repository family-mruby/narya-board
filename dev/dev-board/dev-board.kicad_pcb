# Repository family-mruby/narya-board

File README.md:

# Narya Board

A dual ESP32 development board featuring both ESP32-WROVER-IE and ESP32-S3-WROOM-1 modules on a single PCB.

## Overview

Narya Board is a versatile hardware platform that integrates two popular ESP32 variants, providing developers with flexibility for WiFi/Bluetooth applications, IoT prototyping, and embedded systems development.

## Features

- **Dual ESP32 Modules:**
  - ESP32-WROVER-IE (16MB Flash) - ESP32 classic with PSRAM
  - ESP32-S3-WROOM-1 (N16R8) - Latest ESP32-S3 with 16MB Flash and 8MB PSRAM
- **Video Output:** NTSC composite video output for retro gaming and multimedia applications
- **Audio Output:** Integrated audio output for sound and music playback
- **USB Host:** USB host interface for connecting peripherals
- **SD Card:** MicroSD card slot for external storage and data logging
- **GROVE Connector:** Standard GROVE connector for easy sensor and module integration
- **KiCad 9.0:** Designed with the latest KiCad EDA suite

## Hardware Specifications

## Block Diagram

### ESP32-WROVER-IE Module
- MCU: ESP32 Dual-core Xtensa LX6
- Flash: 16MB
- PSRAM: 8MB

### ESP32-S3-WROOM-1 Module
- MCU: ESP32-S3 Dual-core Xtensa LX7
- Flash: 16MB (N16)
- PSRAM: 8MB (R8)

## Project Structure

```
narya-board/
├── dev/
│   └── dev-board/              # Main KiCad project
│       ├── dev-board.kicad_pcb # PCB layout
│       ├── dev-board.kicad_sch # Main schematic
│       ├── dev-board.kicad_pro # KiCad project file
│       ├── S3_peripheral.kicad_sch        # ESP32-S3 peripheral circuits
│       ├── wrover_peripheral.kicad_sch   # WROVER peripheral circuits
│       ├── kicad/              # Custom libraries and footprints
│       └── production/         # Manufacturing files
│           ├── dev-board.zip   # Gerber files for fabrication
│           └── netlist.ipc     # IPC netlist
├── LICENSE
└── README.md
```

## History

### v3.0 dev R3

## License

This project is licensed under the CERN-OHL-S - see the [LICENSE](LICENSE) file for details.

---

**Note:** This is a hardware development project. Ensure you have appropriate knowledge of electronics and safety precautions when working with these modules.

## KiCad design dev/dev-board/dev-board.kicad_pcb

Parts:
C1, C4, C5, C6, C7, C8, C11, C33, C34, C38: 0.1uF; C_0603_1608Metric; LCSC Part C14663
C2, C3: 10uF; C_0603_1608Metric; LCSC Part C19702
C12: DNP; C_0603_1608Metric; not fitted
C35, C36: 22uF; C_0603_1608Metric; LCSC Part C84419
D2: LED RED; LED_0603_1608Metric; LCSC Part C2286
Q1, Q2, Q3, Q4: BSS138; SOT-23; LCSC Part C82045
R1, R6, R7, R37: 5.1K; R_0603_1608Metric; LCSC Part C23186
R2, R3, R4, R5, R8, R9, R10, R11, R38: 10K; R_0603_1608Metric; LCSC Part C25804
R35: 2K; R_0603_1608Metric; LCSC Part C22975
R42: 0; R_0603_1608Metric; LCSC Part C21189
SW1, SW2, SW3, SW4: TS342A2P; KEY-SMD_L3.9-W3.0-LS5.0; LCSC Part C5373431
SW9: GT-TC018A-H0375-L1; SW-SMD_L4.7-W3.5-P3.35-EH; LCSC Part C963235
U1: ESP32-WROVER-IE(16MB); WIFI-SMD_ESP32-WROVER-IE8MB; LCSC Part C701352
U2: ESP32-S3-WROOM-1(N16R8); WIRELM-SMD_ESP32-S3-WROOM-1; LCSC Part C2913202
U3, U14: CH340C; SOP-16_L10.0-W3.9-P1.27-LS6.0-BL; LCSC Part C84681
U4: TPS2065CDBV; SOT-23-5; LCSC Part C353882
U5: AP7361C-33E; SOT-223-3_TabPin2; LCSC Part C150719
U6, U16: PESD5V0U2BT; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C2905622
U7: PESD5V0S1BA_C5261083; SOD-323_L1.7-W1.3-LS2.5-BI; LCSC Part C5261083
USBC1, USBC2: TYPE-C-31-M-12; USB-C_SMD-TYPE-C-31-M-12_1_Small; LCSC Part C165948

Connections:
+3V3: C3.1, C4.2, C5.2, C6.2, C33.1, C34.1, C35.1, C36.1, C38.2, R8.1, R9.1, R11.1, R35.1, R38.1, U1.2 (3V3), U2.2 (3V3), U3.4 (V3), U3.16 (VCC), U5.3 (VO), U14.4 (V3), U14.16 (VCC); also elsewhere on the board
/CC1-1: R6.1, USBC1.A5 (CC1)
/CC1-2: R1.1, USBC2.A5 (CC1)
/CC2-1: R7.1, USBC1.B5 (CC2)
/CC2-2: R37.1, USBC2.B5 (CC2)
/D+1: U3.5 (D+), U6.2, USBC1.A6 (DP1), USBC1.B6 (DP2)
/D+2: U14.5 (D+), U16.2, USBC2.A6 (DP1), USBC2.B6 (DP2)
/D-1: U3.6 (D-), U6.1, USBC1.A7 (DN1), USBC1.B7 (DN2)
/D-2: U14.6 (D-), U16.1, USBC2.A7 (DN1), USBC2.B7 (DN2)
/DTR1: Q4.2 (S), R3.2, U3.13 (~DTR)
/DTR2: Q2.2 (S), R2.2, U14.13 (~DTR)
/RTS1: Q3.2 (S), R5.2, U3.14 (~RTS)
/RTS2: Q1.2 (S), R4.2, U14.14 (~RTS)
/RX1: U2.37 (TXD0), U3.3 (RXD)
/RX2: U1.35 (TXD0), U14.3 (RXD)
/S3-ButtonCancel: U2.38 (IO2); also elsewhere on the board
/S3-ButtonDown: U2.7 (IO7); also elsewhere on the board
/S3-ButtonEnter: U2.12 (IO8); also elsewhere on the board
/S3-ButtonUp: U2.6 (IO6); also elsewhere on the board
/S3-EN: C8.1, Q3.3 (D), R9.2, SW3.2, SW9.2, U2.3 (EN)
/S3-I2C1-SCL: U2.23 (IO21); also elsewhere on the board
/S3-I2C1-SDA: U2.22 (IO14); also elsewhere on the board
/S3-I2C2-SCL: U2.25 (IO48); also elsewhere on the board
/S3-I2C2-SDA: U2.24 (IO47); also elsewhere on the board
/S3-IO0: C11.2, Q4.3 (D), SW1.2, U2.27 (IO0)
/S3-MTCK: U2.32 (IO39); also elsewhere on the board
/S3-MTDI: U2.34 (IO41); also elsewhere on the board
/S3-MTDO: U2.33 (IO40); also elsewhere on the board
/S3-MTMS: U2.35 (IO42); also elsewhere on the board
/S3-ResetSub: R42.2, U2.5 (IO5)
/S3-SD-CD: U2.31 (IO38); also elsewhere on the board
/S3-SPI3-CS0: U2.8 (IO15); also elsewhere on the board
/S3-SPI3-MISO: U2.11 (IO18); also elsewhere on the board
/S3-SPI3-MOSI: U2.9 (IO16); also elsewhere on the board
/S3-SPI3-SCLK: U2.10 (IO17); also elsewhere on the board
/S3-StatLED1: U2.4 (IO4); also elsewhere on the board
/S3-USB-D+: U2.14 (IO20); also elsewhere on the board
/S3-USB-D-: U2.13 (IO19); also elsewhere on the board
/S3-USB-PWSW: U2.39 (IO1); also elsewhere on the board
/SPI-CS0: R11.2, U1.36 (IO22), U2.18 (IO10)
/SPI-MISO: U1.30 (IO18), U2.21 (IO13)
/SPI-MOSI: U1.33 (IO21), U2.19 (IO11)
/SPI-SCLK: U1.31 (IO19), U2.20 (IO12)
/SPI-SYNC: R38.2, U1.37 (IO23), U2.17 (IO9)
/TX1: U2.36 (RXD0), U3.2 (TXD)
/TX2: U1.34 (RXD0), U14.2 (TXD)
/WR-EN: C7.1, Q1.3 (D), R8.2, R42.1, SW4.2, U1.3 (EN)
/WR-I2S-BLK: U1.8 (IO32); also elsewhere on the board
/WR-I2S-DOUT: U1.12 (IO27); also elsewhere on the board
/WR-I2S-WS: U1.9 (IO33); also elsewhere on the board
/WR-IO0: C12.2, Q2.3 (D), SW2.2, U1.25 (IO0)
/WR-IO4: U1.26 (IO4); also elsewhere on the board
/WR-IO5: U1.29 (IO5); also elsewhere on the board
/WR-IO12: U1.14 (IO12); also elsewhere on the board
/WR-IO13: U1.16 (IO13); also elsewhere on the board
/WR-IO14: U1.13 (IO14); also elsewhere on the board
/WR-IO15: U1.23 (IO15); also elsewhere on the board
/WR-IO26: U1.11 (IO26); also elsewhere on the board
/WR-IO34: U1.6 (IO34); also elsewhere on the board
/WR-IO35: U1.7 (IO35); also elsewhere on the board
/WR-IO36: U1.4 (SENSOR_VP); also elsewhere on the board
/WR-IO39: U1.5 (SENSOR_VN); also elsewhere on the board
/WR-NTSC: U1.10 (IO25); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.1, C7.2, C8.2, C11.1, C12.1, C33.2, C34.2, C35.2, C36.2, C38.1, D2.1 (K), R1.2, R6.2, R7.2, R37.2, SW1.1, SW2.1, SW3.1, SW4.1, SW9.1, SW9.3, SW9.4, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.1 (GND), U2.40 (GND), U2.41 (GND), U3.1 (GND), U4.2 (GND), U5.2 (GND), U6.3, U7.2, U14.1 (GND), U16.3, USBC1.1 (EH), USBC1.2 (EH), USBC1.3 (EH), USBC1.4 (EH), USBC1.A1B12 (GND), USBC1.B1A12 (GND), USBC2.1 (EH), USBC2.2 (EH), USBC2.3 (EH), USBC2.4 (EH), USBC2.A1B12 (GND), USBC2.B1A12 (GND); also elsewhere on the board
unnamed: D2.2 (A), R35.2
unnamed: Q1.1 (G), R2.1
unnamed: Q2.1 (G), R4.1
unnamed: Q3.1 (G), R3.1
unnamed: Q4.1 (G), R5.1
unnamed: R10.2, U4.3 (~FLT)
VBUS: C1.1, R10.1, U4.4 (EN), U4.5 (IN), U7.1, USBC1.A4B9 (VBUS), USBC1.B4A9 (VBUS)
VSYS: C2.1, U4.1 (OUT), U5.1 (VI); also elsewhere on the board

Notes on the sheet:
ESP32電源用
オープンドレイン設定
USB側に120uF配置

Parts:
C9, C10, C13, C15, C16, C17, C18, C39: 0.1uF; C_0603_1608Metric; LCSC Part C14663
C14: 120uF; CAP-SMD_BD6.3-L6.6-W6.6-LS7.2-R-RD; LCSC Part C250087
C19: 10uF; C_0603_1608Metric; LCSC Part C19702
Card1: TF PUSH; TF-SMD_TF-PUSH; LCSC Part C393941
D1: LED GREEN; LED_0805_2012Metric; LCSC Part C2297
D3, D4: LED RED; LED_0603_1608Metric; LCSC Part C2286
J1: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical; not fitted
J2: Conn_01x02_Socket; PinSocket_1x02_P2.54mm_Vertical; not fitted
P1: HDR-IDC-2.54-2X5P; IDC-TH_10P-P2.54_C5665; LCSC Part C5665; not fitted
R12, R13, R14, R17, R18, R20, R21, R22, R23, R24, R25, R26: 10K; R_0603_1608Metric; LCSC Part C25804
R15, R39, R40, R41: 0; R_0603_1608Metric; LCSC Part C21189
R16, R19, R36: 2K; R_0603_1608Metric; LCSC Part C22975
R27: 22; R_0603_1608Metric; LCSC Part C23345
SW5, SW6, SW7, SW8: TS342A2P; KEY-SMD_L3.9-W3.0-LS5.0; LCSC Part C5373431
TP1: TestPoint; TestPoint_Pad_D1.0mm; not fitted
U8, U9: ZX-HY2.0-4PWZ; CONN-TH_4P-P2.00_ZX-HY2.0-4PWZ; LCSC Part C7429589
U10: TPS2065CDBV; SOT-23-5; LCSC Part C353882
U11: PESD5V0U2BT; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C2905622
U12: PESD5V0S1BA_C5261083; SOD-323_L1.7-W1.3-LS2.5-BI; LCSC Part C5261083
U15: RX8900CE_UB0; SMD-10_L3.2-W2.5-BL_EPSON_RX8900CE; LCSC Part C5903517
USB2: USB-231-ARY; USB-A-TH_USB-231-ARY; LCSC Part C720525

Connections:
+3V3: C9.1, C18.1, C19.1, C39.2, Card1.4 (VDD), J1.3, P1.1, R12.1, R13.2, R14.2, R20.1, R21.2, R22.2, R23.2, R24.2, R25.1, R26.2, U15.2 (VDD); also elsewhere on the board
/S3-ButtonCancel: R24.1, SW6.2; also elsewhere on the board
/S3-ButtonDown: R22.1, SW8.2; also elsewhere on the board
/S3-ButtonEnter: R23.1, SW7.2; also elsewhere on the board
/S3-ButtonUp: R21.1, SW5.2; also elsewhere on the board
/S3-I2C1-SCL: R14.1, U8.4, U15.5 (SCL); also elsewhere on the board
/S3-I2C1-SDA: R13.1, U8.3, U15.7 (SDA); also elsewhere on the board
/S3-I2C2-SCL: U9.4; also elsewhere on the board
/S3-I2C2-SDA: U9.3; also elsewhere on the board
/S3-MTCK: P1.4, R39.2; also elsewhere on the board
/S3-MTDI: P1.8; also elsewhere on the board
/S3-MTDO: P1.6, R15.2; also elsewhere on the board
/S3-MTMS: P1.2; also elsewhere on the board
/S3-SD-CD: Card1.9 (CD), R26.1; also elsewhere on the board
/S3-SPI3-CS0: Card1.2 (CD/DAT3), R25.2; also elsewhere on the board
/S3-SPI3-MISO: Card1.7 (DAT0); also elsewhere on the board
/S3-SPI3-MOSI: Card1.3 (CMD), R20.2; also elsewhere on the board
/S3-SPI3-SCLK: R27.1; also elsewhere on the board
/S3-StatLED1: R19.2; also elsewhere on the board
/S3-USB-D+: U11.1, USB2.3 (D+); also elsewhere on the board
/S3-USB-D-: U11.2, USB2.2 (D-); also elsewhere on the board
/S3-USB-PWSW: R17.1, U10.4 (EN); also elsewhere on the board
GND: C9.2, C10.1, C13.1, C14.2, C15.1, C16.2, C17.1, C18.2, C19.2, C39.1, Card1.6 (VSS), Card1.10, Card1.11, Card1.12, Card1.13, D1.1 (K), D3.1 (K), D4.1 (K), J2.2, P1.3, P1.5, P1.7, P1.9, R17.2, R41.1, SW5.1, SW6.1, SW7.1, SW8.1, U8.1, U9.1, U10.2 (GND), U11.3, U12.2, U15.9 (GND), USB2.4 (GND), USB2.5 (GND), USB2.6 (GND); also elsewhere on the board
unnamed: Card1.5 (CLX), R27.2
unnamed: D1.2 (A), R19.1
unnamed: D3.2 (A), R36.2
unnamed: D4.2 (A), R16.1
unnamed: C13.2, J1.2, U9.2
unnamed: C17.2, J2.1, R40.2
unnamed: R16.2, R39.1
unnamed: C14.1, C16.1, R36.1, U10.1 (OUT), U12.1, USB2.1 (VBUS)
unnamed: R18.2, U10.3 (~FLT)
unnamed: R41.2, U15.1 (FOE)
unnamed: TP1.1, U15.4 (FOUT)
unnamed: R40.1, U15.3 (VBAT)
unnamed: R12.2, R15.1, U15.10 (~INT)
VSYS: C10.2, C15.2, J1.1, R18.1, U8.2, U10.5 (IN); also elsewhere on the board

Notes on the sheet:
左から1

Parts:
AV1: AV-5; CONN-TH_AV-5; LCSC Part C18080
Audio1: PJ-327C-4A; AUDIO-SMD_PJ-327C-4A; LCSC Part C145813
C20, C23, C24, C25, C28: 0.1uF; C_0603_1608Metric; LCSC Part C14663
C21, C22, C26, C27: 10uF; C_0603_1608Metric; LCSC Part C19702
C29, C30: 2.2uF; C_0603_1608Metric; LCSC Part C23630
C31, C32: 2.2nF; C_0603_1608Metric; LCSC Part C1604
C37: DNP; C_0603_1608Metric; not fitted
J5: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical; not fitted
LDO1: ME6211C33M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL; LCSC Part C82942
R28, R30, R31, R32: 22; R_0603_1608Metric; LCSC Part C23345
R29, R33: 470; R_0603_1608Metric; LCSC Part C23179
R34: 10K; R_0603_1608Metric; LCSC Part C25804
TP5: TestPoint; TestPoint_Pad_D1.0mm; not fitted
U13: PCM5102APWR; TSSOP-20_L6.5-W4.4-P0.65-LS6.4-BL; LCSC Part C107671

Connections:
+3V3: C20.1, C21.1, C27.2, C28.2, J5.1, R34.1, U13.20 (DVDD); also elsewhere on the board
/WR-I2S-BLK: R30.1; also elsewhere on the board
/WR-I2S-DOUT: R31.1; also elsewhere on the board
/WR-I2S-WS: R32.1; also elsewhere on the board
/WR-IO4: J5.11; also elsewhere on the board
/WR-IO5: J5.17; also elsewhere on the board
/WR-IO12: J5.5; also elsewhere on the board
/WR-IO13: J5.15; also elsewhere on the board
/WR-IO14: J5.7; also elsewhere on the board
/WR-IO15: J5.9; also elsewhere on the board
/WR-IO26: J5.13; also elsewhere on the board
/WR-IO34: J5.6; also elsewhere on the board
/WR-IO35: J5.4; also elsewhere on the board
/WR-IO36: J5.10; also elsewhere on the board
/WR-IO39: J5.8; also elsewhere on the board
/WR-NTSC: R28.2, TP5.1; also elsewhere on the board
GND: AV1.1, Audio1.1, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.1, C28.1, C31.2, C32.2, C37.2, J5.2, J5.3, J5.12, J5.19, LDO1.2 (VSS), U13.9 (AGND), U13.10 (DEMP), U13.11 (FLT), U13.12 (SCK), U13.16 (FMT), U13.19 (DGND); also elsewhere on the board
unnamed: AV1.2, C37.1, R28.1
unnamed: Audio1.2, Audio1.4, C31.1, R33.2
unnamed: Audio1.3, C32.1, R29.2
unnamed: C22.1, C23.1, LDO1.5 (VOUT), U13.1 (CPVDD), U13.8 (AVDD)
unnamed: R30.2, U13.13 (BCK)
unnamed: C29.1, U13.4 (CAPM)
unnamed: C29.2, U13.2 (CAPP)
unnamed: C30.2, U13.3 (CPGND)
unnamed: R31.2, U13.14 (DIN)
unnamed: C25.1, C26.1, U13.18 (LDOO)
unnamed: R32.2, U13.15 (LRCK)
unnamed: R33.1, U13.6 (OUTL)
unnamed: R29.1, U13.7 (OUTR)
unnamed: C30.1, U13.5 (VNEG)
unnamed: R34.2, U13.17 (XSMT)
VSYS: C24.1, J5.14, LDO1.1 (VIN), LDO1.3 (CE); also elsewhere on the board

Notes on the sheet:
ナノ注意

Board: 4 copper layers, 90.0 x 70.0 mm, 131 parts (0 on the bottom side), 100 nets.

Other parts of the board:
REF1, REF2, REF3, REF4: MountingHole_3.2mm_M3

File dev/dev-board/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
AUDIO1,AUDIO-SMD_PJ-327C-4A,1,PJ-327C-4A,C145813
AV1,CONN-TH_AV-5,1,AV-5,C18080
"C1, C10, C11, C13, C15, C16, C17, C18, C20, C23, C24, C25, C28, C33, C34, C38, C39, C4, C5, C6, C7, C8, C9",0603,23,0.1uF,C14663
C14,CAP-SMD_BD6.3-L6.6-W6.6-LS7.2-R-RD,1,120uF,C250087
"C19, C2, C21, C22, C26, C27, C3",0603,7,10uF,C19702
"C29, C30",0603,2,2.2uF,C23630
"C31, C32",0603,2,2.2nF,C1604
"C35, C36",0603,2,22uF,C84419
CARD1,TF-SMD_TF-PUSH,1,TF PUSH,C393941
D1,0805,1,LED GREEN,C2297
"D2, D3, D4",0603,3,LED RED,C2286
LDO1,SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL,1,ME6211C33M5G-N,C82942
"Q1, Q2, Q3, Q4",SOT-23,4,BSS138,C82045
"R1, R37, R6, R7",0603,4,5.1K,C23186
"R10, R11, R12, R13, R14, R17, R18, R2, R20, R21, R22, R23, R24, R25, R26, R3, R34, R38, R4, R5, R8, R9",0603,22,10K,C25804
"R15, R39, R40, R41, R42",0603,5,0,C21189
"R16, R19, R35, R36",0603,4,2K,C22975
"R27, R28, R30, R31, R32",0603,5,22,C23345
"R29, R33",0603,2,470,C23179
"SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8",KEY-SMD_L3.9-W3.0-LS5.0,8,TS342A2P,C5373431
SW9,SW-SMD_L4.7-W3.5-P3.35-EH,1,GT-TC018A-H0375-L1,C963235
U1,WIFI-SMD_ESP32-WROVER-IE8MB,1,ESP32-WROVER-IE(16MB),C701352
"U10, U4",SOT-23-5,2,TPS2065CDBV,C353882
"U11, U16, U6",SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,3,PESD5V0U2BT,C2905622
"U12, U7",SOD-323_L1.7-W1.3-LS2.5-BI,2,PESD5V0S1BA_C5261083,C5261083
U13,TSSOP-20_L6.5-W4.4-P0.65-LS6.4-BL,1,PCM5102APWR,C107671
"U14, U3",SOP-16_L10.0-W3.9-P1.27-LS6.0-BL,2,CH340C,C84681
U15,SMD-10_L3.2-W2.5-BL_EPSON_RX8900CE,1,RX8900CE_UB0,C5903517
U2,WIRELM-SMD_ESP32-S3-WROOM-1,1,ESP32-S3-WROOM-1(N16R8),C2913202
U5,SOT-223-3_TabPin2,1,AP7361C-33E,C150719
"U8, U9",CONN-TH_4P-P2.00_ZX-HY2.0-4PWZ,2,ZX-HY2.0-4PWZ,C7429589
USB2,USB-A-TH_USB-231-ARY,1,USB-231-ARY,C720525
"USBC1, USBC2",USB-C_SMD-TYPE-C-31-M-12_1_Small,2,TYPE-C-31-M-12,C165948

## Commit log

2025-10-02 add kicad files
2025-10-08 making CAD
2025-10-11 finish cad. 1st step. add symbol,footprint files
2025-10-11 complete BOM
2025-10-11 change board size. change C14
2025-11-05 fix LCSC num, improve cad
2025-11-11 release candidadte
2026-02-13 add lib
2026-02-22 update schematics
2026-02-22 designing R2 board
2026-02-23 wiring donw. checking DRC
2026-02-23 checking before release
2026-02-24 r2 candidate
2026-02-24 r2 candidate (fix CH340 V3-VCC)
2026-02-24 r2 candidate (fix silk, add via around ESP32 GND pad)
2026-02-26 add schematics of v2-dev-r2
2026-02-28 add bom.csv and positions.csv for production
2026-03-29 update for v3r3
2026-03-30 v3 dev r3 candidate
2026-04-02 v3 dev r3 candidate2
2026-04-02 update board image
2026-04-02 add schematics
